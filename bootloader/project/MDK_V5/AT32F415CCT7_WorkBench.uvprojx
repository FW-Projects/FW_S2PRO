# Keil uVision project AT32F415CCT7_WorkBench.uvprojx, settings and files
target AT32F415CCT7_WorkBench (6230000::V6.23::ARMCLANG)
  device: -AT32F415CCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415CCT7_WorkBench +hex
  AfterMake: D:\Sonix_project\BF05-master\BF05-master\app\project\MDK_V5\keil5_disp_size_bar.exe
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415CCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c wk_crc.c wk_usart.c wk_debug.c flash.c iap.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f415_crc.c at32f415_crm.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_usart.c at32f415_debug.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
